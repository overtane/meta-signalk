# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

SUMMARY = "An implementation of a [Signal K](http://signalk.org) server for boats."
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# The following license files were not able to be identified and are
# represented as "Unknown" below, you will need to check them yourself:
#   LICENSE
#   node_modules/xml2js/node_modules/sax/LICENSE
#   node_modules/colors/LICENSE
#   node_modules/@signalk/freeboard-sk/LICENSE
#   node_modules/@signalk/instrumentpanel/LICENSE
#   node_modules/@signalk/maptracker/LICENSE
#   node_modules/@signalk/maptracker/node_modules/@signalk/client/LICENSE
#   node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/LICENSE
#   node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/qs/LICENSE
#   node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/lodash/LICENSE
#   node_modules/@signalk/maptracker/node_modules/d3/LICENSE
#   node_modules/@signalk/maptracker/node_modules/jquery/LICENSE.txt
#   node_modules/@signalk/maptracker/node_modules/jquery/external/sizzle/LICENSE.txt
#   node_modules/@signalk/maptracker/node_modules/leaflet/src/copyright.js
#   node_modules/@signalk/set-system-time/LICENSE
#   node_modules/@signalk/signalk-schema/LICENSE
#   node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.APACHE2
#   node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/node_modules/sprintf-js/LICENSE
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/esprima/LICENSE.BSD
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/LICENSE
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/LICENSE
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/doc/readme/license.md
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/LICENSE
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.isequal/LICENSE
#   node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.get/LICENSE
#   node_modules/@signalk/signalk-schema/node_modules/tv4/LICENSE.txt
#   node_modules/@signalk/signalk-schema/node_modules/lodash/LICENSE
#   node_modules/@signalk/client/LICENSE
#   node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/LICENSE
#   node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/@signalk/client/node_modules/superagent/node_modules/qs/LICENSE
#   node_modules/@signalk/client/node_modules/lodash/LICENSE
#   node_modules/@signalk/nmea0183-signalk/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.APACHE2
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/node_modules/sprintf-js/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/esprima/LICENSE.BSD
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/doc/readme/license.md
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.isequal/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.get/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/tv4/LICENSE.txt
#   node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/lodash/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/async/node_modules/lodash/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/cjson/node_modules/jsonlint/node_modules/nomnom/node_modules/underscore/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/LICENSE.BSD
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/LICENSE.source-map
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/node_modules/estraverse/LICENSE.BSD
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/node_modules/source-map/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/node_modules/source-map/node_modules/amdefine/LICENSE
#   node_modules/@signalk/nmea0183-signalk/node_modules/split/node_modules/through/LICENSE.APACHE2
#   node_modules/@signalk/nmea0183-signalk/node_modules/lodash/LICENSE
#   node_modules/@signalk/zones/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.APACHE2
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/node_modules/sprintf-js/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/esprima/LICENSE.BSD
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/doc/readme/license.md
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.isequal/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.get/LICENSE
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/tv4/LICENSE.txt
#   node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/lodash/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/qs/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/nan/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/node_modules/abbrev/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.BSD
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.APACHE2
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/aws-sign2/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/boom/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/boom/node_modules/hoek/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/hoek/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/sntp/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/sntp/node_modules/hoek/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/node_modules/hoek/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/caseless/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/oauth-sign/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/isstream/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/lib/LICENSE-jsbn
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/node_modules/jsbn/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/bcrypt-pbkdf/node_modules/tweetnacl/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/tweetnacl/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/asn1/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/dashdash/LICENSE.txt
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jsbn/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/extsprintf/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/node_modules/extsprintf/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tunnel-agent/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tough-cookie/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/forever-agent/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/qs/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/block-stream/LICENCE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/block-stream/LICENCE
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/isemail/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/hoek/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/topo/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/topo/node_modules/hoek/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/jwa/node_modules/ecdsa-sig-formatter/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/jwa/node_modules/buffer-equal-constant-time/LICENSE.txt
#   node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/lodash.once/LICENSE
#   node_modules/@signalk/sk-simple-token-security/node_modules/lodash/LICENSE
#   node_modules/@signalk/n2k-signalk/LICENSE.txt
#   node_modules/@signalk/n2k-signalk/node_modules/JSONStream/LICENSE.APACHE2
#   node_modules/@signalk/n2k-signalk/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2
#   node_modules/@signalk/n2k-signalk/node_modules/through/LICENSE.APACHE2
#   node_modules/@signalk/signalk-to-nmea0183/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._isiterateecall/LICENSE.txt
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/LICENSE.txt
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/node_modules/lodash._getnative/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/node_modules/lodash.isarguments/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/node_modules/lodash.isarray/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash._basecopy/LICENSE.txt
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._basecreate/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/diff/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/json3/LICENSE
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md
#   node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/fs.realpath/LICENSE
#   node_modules/@signalk/playground/LICENSE
#   node_modules/body-parser/node_modules/qs/LICENSE
#   node_modules/serialport/node_modules/nan/LICENSE.md
#   node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.BSD
#   node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.APACHE2
#   node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/LICENSE
#   node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/serialport/node_modules/prebuild-install/node_modules/detect-libc/LICENSE
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/LICENSE
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/LICENSE.md
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/LICENSE
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/serialport/node_modules/prebuild-install/node_modules/tunnel-agent/LICENSE
#   node_modules/mdns/node_modules/nan/LICENSE.md
#   node_modules/split/node_modules/through/LICENSE.APACHE2
#   node_modules/through/LICENSE.APACHE2
#   node_modules/pem/LICENSE
#   node_modules/pem/node_modules/md5/LICENSE
#   node_modules/pem/node_modules/md5/node_modules/charenc/LICENSE.mkd
#   node_modules/pem/node_modules/md5/node_modules/crypt/LICENSE.mkd
#   node_modules/ejson/node_modules/underscore/LICENSE
#   node_modules/stream-throttle/LICENSE
#   node_modules/express/node_modules/body-parser/node_modules/qs/LICENSE
#   node_modules/express/node_modules/qs/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/nan/LICENSE.md
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.BSD
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.APACHE2
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/detect-libc/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/LICENSE.md
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/LICENSE
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/process-nextick-args/license.md
#   node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tunnel-agent/LICENSE
#   node_modules/canboatjs/node_modules/split/node_modules/through/LICENSE.APACHE2
#   node_modules/canboatjs/node_modules/socketcan/node_modules/xml2js/node_modules/sax/LICENSE
#   node_modules/canboatjs/node_modules/socketcan/node_modules/nan/LICENSE.md
#   node_modules/canboatjs/node_modules/lodash/LICENSE
#   node_modules/lodash/LICENSE
#   public/jquery/LICENSE.txt
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.
LICENSE = "ISC & MIT & Apache-2.0 & apache20 & Unlicense & PD & WTFPL \
& Unknown & BSD-2-Clause & BSD-3-Clause & (BSD-3-Clause | MIT)"
LIC_FILES_CHKSUM = "file://LICENSE;md5=34f8c1142fd6208a8be89399cb521df9 \
                    file://node_modules/cors/LICENSE;md5=43b5353b7cba327feed269fae6433cc9 \
                    file://node_modules/cors/node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/cors/node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/xml2js/LICENSE;md5=d9fc599c8d9e6f8665063862aac66dfc \
                    file://node_modules/xml2js/node_modules/xmlbuilder/LICENSE;md5=eb65a7137aed46eac98ceb8cb8b057a1 \
                    file://node_modules/xml2js/node_modules/sax/LICENSE;md5=326d5674181c4bb210e424772c60fa80 \
                    file://node_modules/colors/LICENSE;md5=4d6f4592bba26cc192f1adfa242a08c7 \
                    file://node_modules/geolib/LICENSE;md5=6170b2002ab00402c434c3dd29e6275c \
                    file://node_modules/@signalk/freeboard-sk/LICENSE;md5=826d41118b35cd3c5a2bdab64d95f13d \
                    file://node_modules/@signalk/simplegauges/LICENSE.txt;md5=56b47d379805ed45bc0c1aff19d7364b \
                    file://node_modules/@signalk/instrumentpanel/LICENSE;md5=d2794c0df5b907fdace235a619d80314 \
                    file://node_modules/@signalk/maptracker/LICENSE;md5=d2794c0df5b907fdace235a619d80314 \
                    file://node_modules/@signalk/maptracker/node_modules/js-quantities/LICENSE;md5=b3664b84c660c7023b2452fa855a5e31 \
                    file://node_modules/@signalk/maptracker/node_modules/js-quantities/lib/jasmine-1.3.1/MIT.LICENSE;md5=ee4bc64f30f3e9d1aed570562d8713e7 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/LICENSE;md5=fa818a259cbed7ce8bc2a22d35a464fc \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/eventemitter3/LICENSE;md5=4089df5313a98fce4a7ff1738a3e4f1a \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/ws/LICENSE;md5=95833e8f03687308b0584a377b9e12b0 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/ws/node_modules/async-limiter/LICENSE;md5=4b83a79a0c223073786a52b5ece4619d \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/ws/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/ws/node_modules/ultron/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/LICENSE;md5=f6030206477cb73726a5c886539edb8b \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/formidable/LICENSE;md5=f4f51c2b640a5b7a159552605e03b887 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/License;md5=7aa505292e2636a9e59d4d3f258f4819 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/asynckit/LICENSE;md5=177bc287fb9558bf3ea50b440c1c86ff \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/cookiejar/LICENSE;md5=dd627a90bb622a86c4b81863f55ae23d \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/methods/LICENSE;md5=c16a7dd9f946172f07086576d135d9d3 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/url/LICENSE;md5=b5cfd06df1b914bc6759a0e56ba220d6 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/url/node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/url/node_modules/querystring/License.md;md5=bfaedb30b2019c45cfdd3095ece6b0d2 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/bluebird/LICENSE;md5=b0aa8f2e45564181abf2267c3401f69c \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/maptracker/node_modules/@signalk/client/node_modules/superagent-promise/LICENSE;md5=fce32416dfbe1a6f29361fab7f82fa33 \
                    file://node_modules/@signalk/maptracker/node_modules/d3/LICENSE;md5=e863f3b38093ec361d12ed4ff001c403 \
                    file://node_modules/@signalk/maptracker/node_modules/jquery/LICENSE.txt;md5=dbcc2c190962327ad79a758ce6bea6f8 \
                    file://node_modules/@signalk/maptracker/node_modules/jquery/external/sizzle/LICENSE.txt;md5=e0b826447077aed12f699bc38c726a44 \
                    file://node_modules/@signalk/maptracker/node_modules/leaflet/LICENSE;md5=1f3b951c5b4d6ede1b26283398ecd14b \
                    file://node_modules/@signalk/maptracker/node_modules/leaflet/src/copyright.js;md5=b9fe014dd9b8700a71adcc5c20b896d2 \
                    file://node_modules/@signalk/maptracker/bower_components/Leaflet.EasyButton/LICENSE;md5=232f36234322b34a34c4029c4e248ddb \
                    file://node_modules/@signalk/maptracker/bower_components/leaflet/LICENSE;md5=1f3b951c5b4d6ede1b26283398ecd14b \
                    file://node_modules/@signalk/set-system-time/LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e \
                    file://node_modules/@signalk/signalk-schema/LICENSE;md5=286209d641e5410796bed8b1ef536e55 \
                    file://node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/jsonparse/LICENSE;md5=566d04c41bfbe138f33e4ffd343e11e4 \
                    file://node_modules/@signalk/signalk-schema/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/signalk-schema/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/LICENSE;md5=fe94f62bb6c28ece1f8db2e7c92eaf11 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/LICENSE;md5=a2f2590d8d82b0fa2b3e2fc5c69d2b81 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/node_modules/sprintf-js/LICENSE;md5=ab40451de4e35c90f1b663b4fbd314a9 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/esprima/LICENSE.BSD;md5=e3c825c932a984958bafbac21e21f984 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/call-me-maybe/LICENSE;md5=7444b82d4127bcd1fa3aa02e9342247b \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/LICENSE;md5=63fb42d95fbf3e2fa9732365ee52e051 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/LICENSE;md5=d9195d9c75e4988d17450bb9162162e7 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/doc/readme/license.md;md5=227b1830dd763325ed1908f5118224ac \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/LICENSE;md5=c840464b0384d89192820ad7b9bd5c80 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.isequal/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.get/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/validator/LICENSE;md5=e421612c5287ca7572b970de16d22ef2 \
                    file://node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/es6-promise/LICENSE;md5=6e73e44544d76c1978a076a8292d031a \
                    file://node_modules/@signalk/signalk-schema/node_modules/tv4-formats/LICENSE;md5=8346aeecc1453f57f91b16b57ba65fec \
                    file://node_modules/@signalk/signalk-schema/node_modules/tv4-formats/node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/@signalk/signalk-schema/node_modules/tv4-formats/node_modules/validator/LICENSE;md5=e421612c5287ca7572b970de16d22ef2 \
                    file://node_modules/@signalk/signalk-schema/node_modules/tv4/LICENSE.txt;md5=4ed2e08cd5ebe66a5b55ef01e88a8fc7 \
                    file://node_modules/@signalk/signalk-schema/node_modules/lodash/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/client/LICENSE;md5=fa818a259cbed7ce8bc2a22d35a464fc \
                    file://node_modules/@signalk/client/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/client/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/client/node_modules/eventemitter3/LICENSE;md5=4089df5313a98fce4a7ff1738a3e4f1a \
                    file://node_modules/@signalk/client/node_modules/ws/LICENSE;md5=95833e8f03687308b0584a377b9e12b0 \
                    file://node_modules/@signalk/client/node_modules/ws/node_modules/async-limiter/LICENSE;md5=4b83a79a0c223073786a52b5ece4619d \
                    file://node_modules/@signalk/client/node_modules/ws/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/client/node_modules/ws/node_modules/ultron/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/@signalk/client/node_modules/superagent/LICENSE;md5=f6030206477cb73726a5c886539edb8b \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/formidable/LICENSE;md5=f4f51c2b640a5b7a159552605e03b887 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/License;md5=7aa505292e2636a9e59d4d3f258f4819 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/form-data/node_modules/asynckit/LICENSE;md5=177bc287fb9558bf3ea50b440c1c86ff \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/cookiejar/LICENSE;md5=dd627a90bb622a86c4b81863f55ae23d \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/methods/LICENSE;md5=c16a7dd9f946172f07086576d135d9d3 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/@signalk/client/node_modules/superagent/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/@signalk/client/node_modules/url/LICENSE;md5=b5cfd06df1b914bc6759a0e56ba220d6 \
                    file://node_modules/@signalk/client/node_modules/url/node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/@signalk/client/node_modules/url/node_modules/querystring/License.md;md5=bfaedb30b2019c45cfdd3095ece6b0d2 \
                    file://node_modules/@signalk/client/node_modules/bluebird/LICENSE;md5=b0aa8f2e45564181abf2267c3401f69c \
                    file://node_modules/@signalk/client/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/client/node_modules/superagent-promise/LICENSE;md5=fce32416dfbe1a6f29361fab7f82fa33 \
                    file://node_modules/@signalk/nmea0183-signalk/LICENSE;md5=83cae75121fdac14fdd8519e68cc7d0b \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/LICENSE;md5=286209d641e5410796bed8b1ef536e55 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/jsonparse/LICENSE;md5=566d04c41bfbe138f33e4ffd343e11e4 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/LICENSE;md5=fe94f62bb6c28ece1f8db2e7c92eaf11 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/LICENSE;md5=a2f2590d8d82b0fa2b3e2fc5c69d2b81 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/node_modules/sprintf-js/LICENSE;md5=ab40451de4e35c90f1b663b4fbd314a9 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/esprima/LICENSE.BSD;md5=e3c825c932a984958bafbac21e21f984 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/call-me-maybe/LICENSE;md5=7444b82d4127bcd1fa3aa02e9342247b \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/LICENSE;md5=63fb42d95fbf3e2fa9732365ee52e051 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/LICENSE;md5=d9195d9c75e4988d17450bb9162162e7 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/doc/readme/license.md;md5=227b1830dd763325ed1908f5118224ac \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/LICENSE;md5=c840464b0384d89192820ad7b9bd5c80 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.isequal/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.get/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/validator/LICENSE;md5=e421612c5287ca7572b970de16d22ef2 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/es6-promise/LICENSE;md5=6e73e44544d76c1978a076a8292d031a \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/tv4-formats/LICENSE;md5=8346aeecc1453f57f91b16b57ba65fec \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/tv4-formats/node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/tv4-formats/node_modules/validator/LICENSE;md5=e421612c5287ca7572b970de16d22ef2 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/tv4/LICENSE.txt;md5=4ed2e08cd5ebe66a5b55ef01e88a8fc7 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/@signalk/signalk-schema/node_modules/lodash/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/moment-timezone/LICENSE;md5=3577232a0c0c3cb5271d3d25cd32fe4e \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/moment-timezone/node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/LICENSE;md5=9a2abe288cd6a0e2ad52643134565f4d \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/async/LICENSE;md5=9ec5487258cc65072647c5488b4d59ad \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/async/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/cjson/node_modules/jsonlint/node_modules/nomnom/LICENSE;md5=0d8c303f84b56d8c334cffb5e6df6444 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/cjson/node_modules/jsonlint/node_modules/nomnom/node_modules/underscore/LICENSE;md5=19bf0f8c9bfb3f719f45bda2c3bdbd71 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/LICENSE.BSD;md5=e74cede38e957fe3e525b0e53a510bcf \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/LICENSE.source-map;md5=e072648d499fc8016e8b190815ad212f \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/node_modules/estraverse/LICENSE.BSD;md5=e74cede38e957fe3e525b0e53a510bcf \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/escodegen/node_modules/source-map/node_modules/amdefine/LICENSE;md5=539b1c7ad0ada7756d6d01b9db20f680 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/jison-lex/node_modules/nomnom/node_modules/colors/MIT-LICENSE.txt;md5=620f21ac3246ae4388eba16b42618cf3 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/jison-lex/node_modules/nomnom/node_modules/underscore/LICENSE;md5=9eaf14330481b774e6e143d7e1f2d02e \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/nomnom/node_modules/colors/MIT-LICENSE.txt;md5=620f21ac3246ae4388eba16b42618cf3 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/nomnom/node_modules/underscore/LICENSE;md5=9eaf14330481b774e6e143d7e1f2d02e \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/ggencoder/node_modules/jison/node_modules/JSONSelect/LICENSE;md5=3835a5e84e354b25bb545f14dd1fa13a \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/split/LICENCE;md5=84ddd974e10adfabbf232e7efb7ed715 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/split/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/split/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/nmea0183-signalk/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/zones/LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/LICENSE;md5=286209d641e5410796bed8b1ef536e55 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/JSONStream/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/JSONStream/node_modules/jsonparse/LICENSE;md5=566d04c41bfbe138f33e4ffd343e11e4 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/LICENSE;md5=fe94f62bb6c28ece1f8db2e7c92eaf11 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/LICENSE;md5=a2f2590d8d82b0fa2b3e2fc5c69d2b81 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/argparse/node_modules/sprintf-js/LICENSE;md5=ab40451de4e35c90f1b663b4fbd314a9 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/js-yaml/node_modules/esprima/LICENSE.BSD;md5=e3c825c932a984958bafbac21e21f984 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/call-me-maybe/LICENSE;md5=7444b82d4127bcd1fa3aa02e9342247b \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/LICENSE;md5=63fb42d95fbf3e2fa9732365ee52e051 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/LICENSE;md5=d9195d9c75e4988d17450bb9162162e7 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/ono/node_modules/format-util/doc/readme/license.md;md5=227b1830dd763325ed1908f5118224ac \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/LICENSE;md5=c840464b0384d89192820ad7b9bd5c80 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.isequal/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/lodash.get/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/z-schema/node_modules/validator/LICENSE;md5=e421612c5287ca7572b970de16d22ef2 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/json-schema-ref-parser/node_modules/es6-promise/LICENSE;md5=6e73e44544d76c1978a076a8292d031a \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/tv4-formats/LICENSE;md5=8346aeecc1453f57f91b16b57ba65fec \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/tv4-formats/node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/tv4-formats/node_modules/validator/LICENSE;md5=e421612c5287ca7572b970de16d22ef2 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/tv4/LICENSE.txt;md5=4ed2e08cd5ebe66a5b55ef01e88a8fc7 \
                    file://node_modules/@signalk/zones/node_modules/@signalk/signalk-schema/node_modules/lodash/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/zones/node_modules/baconjs/LICENSE;md5=e933322d89a283f685fb71a005880efc \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/type-is/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/type-is/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/type-is/node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/LICENSE;md5=c970d30155ebbdb1903e6de8c0666e18 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/body-parser/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/LICENSE;md5=4665b5424ab734549385bae891f8d35d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/nan/LICENSE.md;md5=d7425f79f415dec8f013aa2869dd7a4e \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/LICENSE;md5=7e13c3cf883a44ebcc74a8f568c0f6fb \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/node_modules/osenv/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/node_modules/osenv/node_modules/os-homedir/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/node_modules/osenv/node_modules/os-tmpdir/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/node_modules/abbrev/LICENSE;md5=e9c0b639498fbe60d17b10099aba77c0 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.BSD;md5=e7a2a325a0069e82aff675bbf74464a0 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/strip-json-comments/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/deep-extend/LICENSE;md5=74959162613f2777f3ef55bdb8b74c89 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/LICENSE;md5=039a23da29f56411e6d75d7b7bc9de13 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/delegates/License;md5=039225978c07bc42e8c0ef2f72b81c09 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/has-unicode/LICENSE;md5=2bab5b1c26e9c44fc4e489bb98cfb196 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/aproba/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/signal-exit/LICENSE.txt;md5=e29e20260a1c78dba16a233048565cde \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/set-blocking/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/aws-sign2/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/LICENSE;md5=715855234c57d97032971adfc0608a07 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/fast-json-stable-stringify/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/fast-deep-equal/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/co/LICENSE;md5=1cb994f27906c83d46a3cc6d9e1d8d6c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/json-schema-traverse/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/har-schema/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/stringstream/LICENSE.txt;md5=3b3d0996fc07ae2d89c4659b9ffcbe2e \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/License;md5=7aa505292e2636a9e59d4d3f258f4819 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/asynckit/LICENSE;md5=177bc287fb9558bf3ea50b440c1c86ff \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/LICENSE;md5=aa3dcddf0039666585d9b80574526e38 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/boom/LICENSE;md5=ccfa8265c53cf13b063280d0917eb517 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/boom/node_modules/hoek/LICENSE;md5=a670c1b0730654cd87189993221cdf0d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/hoek/LICENSE;md5=a670c1b0730654cd87189993221cdf0d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/sntp/LICENSE;md5=4ce2a96fc8315e28c47cc7b470e4ccdb \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/sntp/node_modules/hoek/LICENSE;md5=a670c1b0730654cd87189993221cdf0d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/LICENSE;md5=26920e2bf2057e454e3ab72a437e564e \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/LICENSE;md5=ccfa8265c53cf13b063280d0917eb517 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/node_modules/hoek/LICENSE;md5=a670c1b0730654cd87189993221cdf0d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/caseless/LICENSE;md5=e9dadf023ba6ebd98e3e0acb6e2470e3 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/aws4/LICENSE;md5=ff6f181928a91d8631d565516b4db3cb \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/oauth-sign/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/is-typedarray/LICENSE.md;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/uuid/LICENSE.md;md5=c9420736e23afb538ba5fbe44197f0b4 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/json-stringify-safe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/isstream/LICENSE.md;md5=1798150b9d70250c42b55b3530e6af2b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/performance-now/license.txt;md5=a07ae1b6dc33215d89a1281ee71c863c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/LICENSE;md5=0d289b6d63cbcc18e4b2af9a5bd28b54 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/lib/LICENSE-jsbn;md5=32052d48bacabd1c02e56c6889082a27 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/bcrypt-pbkdf/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/asn1/LICENSE;md5=5ce2f42143c298495637e28e40cd5462 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/dashdash/LICENSE.txt;md5=ebce61c1a0900d798daaf5853c69ce72 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/getpass/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/LICENSE;md5=04fce49dd88d841ceb36616ab9789ce0 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tunnel-agent/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tough-cookie/LICENSE;md5=ceb9c658d7a5d62bee6628c46832168e \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tough-cookie/node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/forever-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/LICENSE;md5=bbd174e5c1525a215e2f38ebfcca16e9 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/uid-number/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/LICENSE;md5=34c65f5b9b91f31827910d3b54bd6497 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/block-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/block-stream/LICENCE;md5=c695aba12d799c74e770d90e1c5d59aa \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/block-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/LICENSE;md5=34c65f5b9b91f31827910d3b54bd6497 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/block-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/block-stream/LICENCE;md5=c695aba12d799c74e770d90e1c5d59aa \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/block-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/cookie-parser/LICENSE;md5=720bd7b9472a2297cd6820c73c71cf3e \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/cookie-parser/node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/LICENSE;md5=b2f0f70e6fe21447621e4283c8aa5af2 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/LICENSE;md5=c72fbd14008b582a9b8b9889460e8b31 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/LICENSE;md5=229550628d4d185279f28a6c29d34cbe \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/isemail/LICENSE;md5=1ff95677d22cc145812abf603aec2b16 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/topo/LICENSE;md5=694d183096514809fda2a1999582eac4 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/joi/node_modules/topo/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/LICENSE;md5=0d71cb15a801bf0e61cb2db5ba63dc6a \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/jwa/LICENSE;md5=0d71cb15a801bf0e61cb2db5ba63dc6a \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/jwa/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/jwa/node_modules/ecdsa-sig-formatter/LICENSE;md5=3e46e4245b62bb1fd440c50c12062a3d \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/jwa/node_modules/ecdsa-sig-formatter/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/jws/node_modules/jwa/node_modules/buffer-equal-constant-time/LICENSE.txt;md5=effafd1e58e518742380952debd9b819 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/lodash.once/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/jsonwebtoken/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/passport-jwt/node_modules/passport-strategy/LICENSE;md5=f694b9c022a5bf0f2c3976a047fed39c \
                    file://node_modules/@signalk/sk-simple-token-security/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/@signalk/sailgauge/LICENSE.txt;md5=56b47d379805ed45bc0c1aff19d7364b \
                    file://node_modules/@signalk/n2k-signalk/LICENSE.txt;md5=7d77efef4079763cab747c520927ca13 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/JSONStream/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/JSONStream/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/JSONStream/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/JSONStream/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/JSONStream/node_modules/jsonparse/LICENSE;md5=566d04c41bfbe138f33e4ffd343e11e4 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/@signalk/n2k-signalk/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/@signalk/signalk-to-nmea0183/LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/LICENSE;md5=31f1cb7731bc1e684e18461ffcb1e916 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/lib/to-iso-string/LICENSE;md5=1ad9cd707834030f4d329402ae948a6a \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/commander/node_modules/graceful-readlink/LICENSE;md5=b0270ddb7ee6643eee76e80113234806 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/escape-string-regexp/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/he/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/supports-color/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/supports-color/node_modules/has-flag/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._isiterateecall/LICENSE.txt;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/LICENSE.txt;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/node_modules/lodash._getnative/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/node_modules/lodash.isarguments/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash.keys/node_modules/lodash.isarray/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._baseassign/node_modules/lodash._basecopy/LICENSE.txt;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/lodash.create/node_modules/lodash._basecreate/LICENSE;md5=f519f8cb155e30cece6b0e75aa6a3a53 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/diff/LICENSE;md5=e6f0309f3f9919cd96cc45a4d4859c54 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/json3/LICENSE;md5=e23ee4c29fcae2eae419990afd891c74 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/mocha/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@signalk/signalk-to-nmea0183/node_modules/baconjs/LICENSE;md5=e933322d89a283f685fb71a005880efc \
                    file://node_modules/@signalk/playground/LICENSE;md5=fa818a259cbed7ce8bc2a22d35a464fc \
                    file://node_modules/body-parser/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/body-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/body-parser/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/body-parser/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/body-parser/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/body-parser/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/body-parser/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/body-parser/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/body-parser/node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/body-parser/node_modules/type-is/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/body-parser/node_modules/type-is/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/body-parser/node_modules/type-is/node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/body-parser/node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/body-parser/node_modules/raw-body/LICENSE;md5=c970d30155ebbdb1903e6de8c0666e18 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/body-parser/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/body-parser/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/body-parser/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/body-parser/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/body-parser/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/body-parser/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/serialport/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/serialport/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/serialport/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/nan/LICENSE.md;md5=e6270b7774528599f2623a4aeb625829 \
                    file://node_modules/serialport/node_modules/promirepl/LICENSE;md5=7c9235e0e2b265ff151142bc57a3e9c0 \
                    file://node_modules/serialport/node_modules/prebuild-install/LICENSE;md5=a75272c6b584d0f8e2c1676b4e72469e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/github-from-package/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/node-abi/LICENSE;md5=950ded031080d1cc5efffec127b7a852 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/node-abi/node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.BSD;md5=e7a2a325a0069e82aff675bbf74464a0 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/strip-json-comments/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/deep-extend/LICENSE;md5=74959162613f2777f3ef55bdb8b74c89 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/LICENSE;md5=039a23da29f56411e6d75d7b7bc9de13 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/delegates/License;md5=039225978c07bc42e8c0ef2f72b81c09 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/has-unicode/LICENSE;md5=2bab5b1c26e9c44fc4e489bb98cfb196 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/aproba/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/signal-exit/LICENSE.txt;md5=e29e20260a1c78dba16a233048565cde \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/set-blocking/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/detect-libc/LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/LICENSE.md;md5=e58dc7a94bb9decf6a7b2ff97d22b213 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/chownr/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/os-homedir/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/which-pm-runs/LICENSE;md5=a2661af2f2ec8fb665254e547ed4ac87 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/decompress-response/license;md5=5b422d6bf88afe88977d04f8bdd4959c \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/decompress-response/node_modules/mimic-response/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/simple-concat/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/serialport/node_modules/prebuild-install/node_modules/tunnel-agent/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/copy-descriptor/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/mute-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/for-own/LICENSE;md5=a9f606f2e3822130012aab1f9c6ed213 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/for-own/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/toggle-array/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/toggle-array/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/info-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/warning-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/time-stamp/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/error-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/LICENSE;md5=c5465ad39efa0df062aecec7009a744b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/LICENSE;md5=4e0921625c33cf4e6990a6416848a6e5 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/is-extendable/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/is-extendable/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/assign-symbols/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/pointer-symbol/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/for-own/LICENSE;md5=a9f606f2e3822130012aab1f9c6ed213 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/for-own/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/map-visit/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/map-visit/node_modules/object-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/map-visit/node_modules/object-visit/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/object-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/object-visit/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/info-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/warning-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/time-stamp/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/error-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/LICENSE;md5=c5465ad39efa0df062aecec7009a744b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-actions/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-actions/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-actions/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/mute-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/info-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/warning-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/time-stamp/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/error-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/LICENSE;md5=c5465ad39efa0df062aecec7009a744b \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/serialport/node_modules/prompt-list/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/mdns/LICENSE;md5=f8b826cbf7f10e902fb7c3e8fc844d4d \
                    file://node_modules/mdns/node_modules/nan/LICENSE.md;md5=365dd94f3b619ca5566e5fb51f32c0e6 \
                    file://node_modules/ws/LICENSE;md5=95833e8f03687308b0584a377b9e12b0 \
                    file://node_modules/ws/node_modules/async-limiter/LICENSE;md5=4b83a79a0c223073786a52b5ece4619d \
                    file://node_modules/ws/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/split/LICENCE;md5=84ddd974e10adfabbf232e7efb7ed715 \
                    file://node_modules/split/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/split/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/primus/LICENSE;md5=831650d583b50b1bd703d1c09fdb4dc5 \
                    file://node_modules/primus/node_modules/yeast/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/primus/node_modules/access-control/LICENSE;md5=831650d583b50b1bd703d1c09fdb4dc5 \
                    file://node_modules/primus/node_modules/access-control/node_modules/millisecond/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/primus/node_modules/access-control/node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/primus/node_modules/eventemitter3/LICENSE;md5=4089df5313a98fce4a7ff1738a3e4f1a \
                    file://node_modules/primus/node_modules/diagnostics/LICENSE.md;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/primus/node_modules/diagnostics/node_modules/colorspace/LICENSE.md;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/primus/node_modules/diagnostics/node_modules/colorspace/node_modules/color/LICENSE;md5=2fdebf76c074642a861bf45bf4a8258e \
                    file://node_modules/primus/node_modules/diagnostics/node_modules/colorspace/node_modules/color/node_modules/color-convert/LICENSE;md5=330031db3ec2b47f6e9d7923b8e1f95b \
                    file://node_modules/primus/node_modules/diagnostics/node_modules/colorspace/node_modules/color/node_modules/color-string/LICENSE;md5=330031db3ec2b47f6e9d7923b8e1f95b \
                    file://node_modules/primus/node_modules/diagnostics/node_modules/colorspace/node_modules/color/node_modules/color-string/node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/primus/node_modules/diagnostics/node_modules/enabled/LICENSE.md;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/primus/node_modules/ultron/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/uuid/LICENSE.md;md5=c9420736e23afb538ba5fbe44197f0b4 \
                    file://node_modules/pem/LICENSE;md5=f5e55ac827d2ea9cf016455bb87c275e \
                    file://node_modules/pem/node_modules/md5/LICENSE;md5=f975764919f5b2859c839414bb6a6f3a \
                    file://node_modules/pem/node_modules/md5/node_modules/charenc/LICENSE.mkd;md5=b8024dcec94c3e11ece8465dd3c94c2a \
                    file://node_modules/pem/node_modules/md5/node_modules/crypt/LICENSE.mkd;md5=b8024dcec94c3e11ece8465dd3c94c2a \
                    file://node_modules/pem/node_modules/md5/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/pem/node_modules/which/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/pem/node_modules/which/node_modules/isexe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/pem/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/pem/node_modules/os-tmpdir/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/errorhandler/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/errorhandler/node_modules/accepts/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/errorhandler/node_modules/accepts/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/errorhandler/node_modules/accepts/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/errorhandler/node_modules/accepts/node_modules/negotiator/LICENSE;md5=6417a862a5e35c17c904d9dda2cbd499 \
                    file://node_modules/errorhandler/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/ejson/LICENSE;md5=831650d583b50b1bd703d1c09fdb4dc5 \
                    file://node_modules/ejson/node_modules/underscore/LICENSE;md5=e5cfca0461b21ca314a0088fd5b2a236 \
                    file://node_modules/morgan/LICENSE;md5=dfc6bf950f998574f853233ae6360c22 \
                    file://node_modules/morgan/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/morgan/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/morgan/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/morgan/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/morgan/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/morgan/node_modules/on-headers/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/morgan/node_modules/basic-auth/LICENSE;md5=42fffe6fe0b70501d52150ebb52113df \
                    file://node_modules/morgan/node_modules/basic-auth/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/stream-throttle/LICENSE;md5=d1970d736837d35397d55e68b40f65a8 \
                    file://node_modules/stream-throttle/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/stream-throttle/node_modules/limiter/LICENSE.txt;md5=0ff8762df2d91ea51bd0350cd9b2016d \
                    file://node_modules/please-upgrade-node/LICENSE;md5=17a1d3575545a1e1c7c7f835388beafe \
                    file://node_modules/baconjs/LICENSE;md5=e933322d89a283f685fb71a005880efc \
                    file://node_modules/express/LICENSE;md5=5513c00a5c36cd361da863dd9aa8875d \
                    file://node_modules/express/node_modules/accepts/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/express/node_modules/accepts/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/express/node_modules/accepts/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/accepts/node_modules/negotiator/LICENSE;md5=6417a862a5e35c17c904d9dda2cbd499 \
                    file://node_modules/express/node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
                    file://node_modules/express/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/express/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/array-flatten/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/express/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/body-parser/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/express/node_modules/body-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/express/node_modules/body-parser/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/body-parser/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/body-parser/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/body-parser/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/body-parser/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/express/node_modules/body-parser/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/express/node_modules/body-parser/node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/express/node_modules/body-parser/node_modules/type-is/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/express/node_modules/body-parser/node_modules/type-is/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/body-parser/node_modules/type-is/node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/express/node_modules/body-parser/node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/LICENSE;md5=c970d30155ebbdb1903e6de8c0666e18 \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/body-parser/node_modules/raw-body/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/express/node_modules/body-parser/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/body-parser/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/express/node_modules/body-parser/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/body-parser/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/body-parser/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/express/node_modules/body-parser/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/express/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
                    file://node_modules/express/node_modules/utils-merge/LICENSE;md5=1cf0906082187f374cb9a63c54eb782c \
                    file://node_modules/express/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/express/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/express/node_modules/merge-descriptors/LICENSE;md5=aaf57ba8c5c9bf256fea7e943991a81a \
                    file://node_modules/express/node_modules/send/LICENSE;md5=df2b0938eba0709b77ac937e2d552b7a \
                    file://node_modules/express/node_modules/send/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/express/node_modules/send/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/send/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/send/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/send/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/send/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/send/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/send/node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
                    file://node_modules/express/node_modules/send/node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/express/node_modules/send/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/send/node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/express/node_modules/send/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/send/node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/express/node_modules/send/node_modules/destroy/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/content-disposition/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/express/node_modules/finalhandler/LICENSE;md5=b506956e5cbfbe0d04f8a5c40107ec89 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/finalhandler/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/finalhandler/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/methods/LICENSE;md5=c16a7dd9f946172f07086576d135d9d3 \
                    file://node_modules/express/node_modules/path-to-regexp/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/express/node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/express/node_modules/proxy-addr/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/express/node_modules/proxy-addr/node_modules/ipaddr.js/LICENSE;md5=88f60a4b6e44cb849b5d907a7664c0ef \
                    file://node_modules/express/node_modules/proxy-addr/node_modules/forwarded/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/express/node_modules/type-is/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/express/node_modules/type-is/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/type-is/node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/express/node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/express/node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/express/node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/express/node_modules/serve-static/LICENSE;md5=27b1707520b14d0bc890f4e75cd387b0 \
                    file://node_modules/express/node_modules/serve-static/node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
                    file://node_modules/express/node_modules/serve-static/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/LICENSE;md5=df2b0938eba0709b77ac937e2d552b7a \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/destroy/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/serve-static/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/file-timestamp-stream/LICENSE;md5=0884975ed0f73b79655d4c087801839d \
                    file://node_modules/file-timestamp-stream/node_modules/ultra-strftime/LICENSE;md5=d4d2a4b1a8d1e1fcc10d1881b8f3621d \
                    file://node_modules/compare-versions/LICENSE;md5=0e2a8ffba75c439b2928fa0fe67769fb \
                    file://node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/canboatjs/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/nan/LICENSE.md;md5=e6270b7774528599f2623a4aeb625829 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/promirepl/LICENSE;md5=7c9235e0e2b265ff151142bc57a3e9c0 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/LICENSE;md5=a75272c6b584d0f8e2c1676b4e72469e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/github-from-package/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/node-abi/LICENSE;md5=950ded031080d1cc5efffec127b7a852 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/node-abi/node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/pump/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.BSD;md5=e7a2a325a0069e82aff675bbf74464a0 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/strip-json-comments/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/deep-extend/LICENSE;md5=74959162613f2777f3ef55bdb8b74c89 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/rc/node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/LICENSE;md5=039a23da29f56411e6d75d7b7bc9de13 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/delegates/License;md5=039225978c07bc42e8c0ef2f72b81c09 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/has-unicode/LICENSE;md5=2bab5b1c26e9c44fc4e489bb98cfb196 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/aproba/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/gauge/node_modules/signal-exit/LICENSE.txt;md5=e29e20260a1c78dba16a233048565cde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/npmlog/node_modules/set-blocking/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/detect-libc/LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/pump/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/LICENSE.md;md5=e58dc7a94bb9decf6a7b2ff97d22b213 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/tar-stream/node_modules/bl/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tar-fs/node_modules/chownr/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/os-homedir/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/which-pm-runs/LICENSE;md5=a2661af2f2ec8fb665254e547ed4ac87 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/decompress-response/license;md5=5b422d6bf88afe88977d04f8bdd4959c \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/decompress-response/node_modules/mimic-response/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/simple-concat/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/simple-get/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prebuild-install/node_modules/tunnel-agent/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/static-extend/node_modules/object-copy/node_modules/copy-descriptor/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/mute-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-ui/node_modules/readline-utils/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/for-own/LICENSE;md5=a9f606f2e3822130012aab1f9c6ed213 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/for-own/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/clone-deep/node_modules/shallow-clone/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/toggle-array/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/toggle-array/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/info-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/warning-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/time-stamp/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/error-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/LICENSE;md5=c5465ad39efa0df062aecec7009a744b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/terminal-paginator/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-swap/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/LICENSE;md5=4e0921625c33cf4e6990a6416848a6e5 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/is-extendable/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/is-extendable/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/split-string/node_modules/extend-shallow/node_modules/assign-symbols/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/set-value/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/pointer-symbol/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/is-plain-object/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/for-own/LICENSE;md5=a9f606f2e3822130012aab1f9c6ed213 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/for-own/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/mixin-object/node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/clone-deep/node_modules/shallow-clone/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/choices-separator/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/map-visit/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/map-visit/node_modules/object-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/map-visit/node_modules/object-visit/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/object-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/collection-visit/node_modules/object-visit/node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/info-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/warning-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/time-stamp/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/error-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/LICENSE;md5=c5465ad39efa0df062aecec7009a744b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-question/node_modules/prompt-choices/node_modules/radio-symbol/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-actions/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-actions/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/prompt-actions/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/LICENSE;md5=446d1cf3de4ea6a42746be233a220a1b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/koalas/LICENSE;md5=b436a81ca02af57e0e362bafa17f4571 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/strip-color/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/mute-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/is-number/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/window-size/node_modules/define-property/node_modules/is-descriptor/node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/readline-utils/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/info-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/log-ok/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/success-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/warning-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/time-stamp/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/error-symbol/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/LICENSE;md5=c5465ad39efa0df062aecec7009a744b \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-hidden/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-white/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgwhite/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bold/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-inverse/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/LICENSE;md5=7874ce928b4b806b68bfe0db60986138 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/lazy-cache/node_modules/set-getter/node_modules/to-object-path/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgcyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-magenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-red/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-black/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgyellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgblack/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-reset/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-green/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-yellow/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bggreen/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-underline/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-italic/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-strikethrough/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-grey/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-blue/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgmagenta/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-gray/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-bgred/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/prompt-radio/node_modules/prompt-checkbox/node_modules/prompt-base/node_modules/log-utils/node_modules/ansi-colors/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/ansi-dim/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/ansi-dim/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/ansi-cyan/LICENSE;md5=12559a9acb747541ab67609d77c0f1de \
                    file://node_modules/canboatjs/node_modules/serialport/node_modules/prompt-list/node_modules/ansi-cyan/node_modules/ansi-wrap/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/canboatjs/node_modules/split/LICENCE;md5=84ddd974e10adfabbf232e7efb7ed715 \
                    file://node_modules/canboatjs/node_modules/split/node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/canboatjs/node_modules/split/node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/canboatjs/node_modules/int64-buffer/LICENSE;md5=399618006b9ae1305f41301709992e5b \
                    file://node_modules/canboatjs/node_modules/socketcan/node_modules/xml2js/LICENSE;md5=d9fc599c8d9e6f8665063862aac66dfc \
                    file://node_modules/canboatjs/node_modules/socketcan/node_modules/xml2js/node_modules/xmlbuilder/LICENSE;md5=eb65a7137aed46eac98ceb8cb8b057a1 \
                    file://node_modules/canboatjs/node_modules/socketcan/node_modules/xml2js/node_modules/sax/LICENSE;md5=326d5674181c4bb210e424772c60fa80 \
                    file://node_modules/canboatjs/node_modules/socketcan/node_modules/nan/LICENSE.md;md5=e6270b7774528599f2623a4aeb625829 \
                    file://node_modules/canboatjs/node_modules/socketcan/docs/assets/vendor/prettify/COPYING;md5=3b83ef96387f14655fc854ddc3c6bd57 \
                    file://node_modules/canboatjs/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://public/bootstrap/LICENSE;md5=7feb871dfe601a665c5c5201d3fa8450 \
                    file://public/jquery/LICENSE.txt;md5=dbcc2c190962327ad79a758ce6bea6f8"

SRC_URI = "npm://registry.npmjs.org;name=signalk-server;version=${PV}"

NPM_SHRINKWRAP := "${THISDIR}/${PN}/npm-shrinkwrap.json"
NPM_LOCKDOWN := "${THISDIR}/${PN}/lockdown.json"

inherit npm

# Must be set after inherit npm since that itself sets S
S = "${WORKDIR}/npmpkg"
LICENSE_${PN}-baconjs = "MIT"
LICENSE_${PN}-body-parser-bytes = "MIT"
LICENSE_${PN}-body-parser-content-type = "MIT"
LICENSE_${PN}-body-parser-debug-ms = "MIT"
LICENSE_${PN}-body-parser-debug = "MIT"
LICENSE_${PN}-body-parser-depd = "MIT"
LICENSE_${PN}-body-parser-http-errors-depd = "MIT"
LICENSE_${PN}-body-parser-http-errors-inherits = "ISC"
LICENSE_${PN}-body-parser-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-body-parser-http-errors-statuses = "MIT"
LICENSE_${PN}-body-parser-http-errors = "MIT"
LICENSE_${PN}-body-parser-iconv-lite = "MIT"
LICENSE_${PN}-body-parser-on-finished-ee-first = "MIT"
LICENSE_${PN}-body-parser-on-finished = "MIT"
LICENSE_${PN}-body-parser-qs = "BSD-3-Clause"
LICENSE_${PN}-body-parser-raw-body-bytes = "MIT"
LICENSE_${PN}-body-parser-raw-body-http-errors-depd = "MIT"
LICENSE_${PN}-body-parser-raw-body-http-errors-inherits = "ISC"
LICENSE_${PN}-body-parser-raw-body-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-body-parser-raw-body-http-errors-statuses = "MIT"
LICENSE_${PN}-body-parser-raw-body-http-errors = "MIT"
LICENSE_${PN}-body-parser-raw-body-iconv-lite = "MIT"
LICENSE_${PN}-body-parser-raw-body-unpipe = "MIT"
LICENSE_${PN}-body-parser-raw-body = "MIT"
LICENSE_${PN}-body-parser-type-is-media-typer = "MIT"
LICENSE_${PN}-body-parser-type-is-mime-types-mime-db = "MIT"
LICENSE_${PN}-body-parser-type-is-mime-types = "MIT"
LICENSE_${PN}-body-parser-type-is = "MIT"
LICENSE_${PN}-body-parser = "MIT"
LICENSE_${PN}-canboatjs-bit-buffer = "MIT"
LICENSE_${PN}-canboatjs-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-debug = "MIT"
LICENSE_${PN}-canboatjs-int64-buffer = "MIT"
LICENSE_${PN}-canboatjs-lodash = "MIT"
LICENSE_${PN}-canboatjs-serialport-bindings = "MIT"
LICENSE_${PN}-canboatjs-serialport-commander = "MIT"
LICENSE_${PN}-canboatjs-serialport-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-nan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-detect-libc = "Apache-2.0"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-expand-template = "WTFPL"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-github-from-package = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-minimist = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-mkdirp-minimist = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-mkdirp = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-node-abi-semver = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-node-abi = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-noop-logger = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-delegates = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-inherits = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-isarray = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-are-we-there-yet = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-console-control-strings = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-aproba = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-console-control-strings = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-has-unicode = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-object-assign = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-signal-exit = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-string-width-code-point-at = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-string-width-strip-ansi = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-string-width = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-strip-ansi = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-code-point-at = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-strip-ansi = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-wide-align-string-width = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge-wide-align = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-gauge = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog-set-blocking = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-npmlog = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-os-homedir = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-pump-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-pump-end-of-stream-once = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-pump-end-of-stream = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-pump-once-wrappy = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-pump-once = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-pump = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-rc-deep-extend = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-rc-ini = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-rc-minimist = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-rc-strip-json-comments = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-rc = "MIT Unknown"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-simple-get-decompress-response-mimic-response = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-simple-get-decompress-response = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-simple-get-once-wrappy = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-simple-get-once = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-simple-get-simple-concat = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-simple-get = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-chownr = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-mkdirp-minimist = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-mkdirp = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-pump-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-pump-end-of-stream-once = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-pump-end-of-stream = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-pump-once-wrappy = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-pump-once = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-pump = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-inherits = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-isarray = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-bl = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-end-of-stream-once = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-end-of-stream = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-inherits = "ISC"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-isarray = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-readable-stream = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream-xtend = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs-tar-stream = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tar-fs = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tunnel-agent-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-tunnel-agent = "Apache-2.0"
LICENSE_${PN}-canboatjs-serialport-prebuild-install-which-pm-runs = "MIT"
LICENSE_${PN}-canboatjs-serialport-prebuild-install = "MIT"
LICENSE_${PN}-canboatjs-serialport-promirepl = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-ansi-cyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-ansi-dim = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-ansi-cyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-component-emitter = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-koalas = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblack-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblack = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblue-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblue = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgcyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgcyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bggreen-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bggreen = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgmagenta-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgmagenta = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgred-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgred = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgwhite-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgwhite = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgyellow-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgyellow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-black-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-black = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-blue-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-blue = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bold-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bold = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-cyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-dim = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-gray = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-green = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-grey-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-grey = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-hidden-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-hidden = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-inverse-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-inverse = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-italic-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-italic = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-magenta-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-magenta = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-red-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-red = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-reset-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-reset = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-strikethrough-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-strikethrough = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-underline-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-underline = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-white-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-white = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-yellow-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-yellow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-error-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-info-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok-ansi-green = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok-success-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-success-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-time-stamp = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-warning-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-actions-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-actions-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-actions = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-for-own-for-in = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-for-own = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-is-plain-object-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-is-plain-object = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-mixin-object-for-in = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-mixin-object-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-mixin-object = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-koalas = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-flatten = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap-is-number-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap-is-number = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-ansi-dim = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-strip-color = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-for-own-for-in = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-for-own = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-is-plain-object-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-is-plain-object = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-mixin-object-for-in = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-mixin-object-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-mixin-object = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-map-visit-object-visit-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-map-visit-object-visit = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-map-visit = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-object-visit-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-object-visit = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-extend-shallow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-is-number-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-is-number = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-koalas = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblack-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblack = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblue-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblue = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgcyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgcyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bggreen-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bggreen = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgmagenta-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgmagenta = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgred-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgred = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgwhite-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgwhite = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgyellow-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgyellow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-black-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-black = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-blue-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-blue = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bold-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bold = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-cyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-dim = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-gray = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-green = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-grey-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-grey = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-hidden-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-hidden = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-inverse-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-inverse = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-italic-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-italic = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-magenta-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-magenta = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-red-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-red = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-reset-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-reset = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-strikethrough-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-strikethrough = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-underline-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-underline = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-white-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-white = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-yellow-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-yellow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-error-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-info-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok-ansi-green = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok-success-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-success-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-time-stamp = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-warning-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-pointer-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-gray = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-green = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-is-windows = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-extend-shallow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-is-plain-object-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-is-plain-object = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-assign-symbols = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-is-extendable-is-plain-object-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-is-extendable-is-plain-object = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-strip-color = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-extend-shallow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblack-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblack = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblue-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblue = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgcyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgcyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bggreen-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bggreen = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgmagenta-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgmagenta = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgred-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgred = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgwhite-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgwhite = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgyellow-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgyellow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-black-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-black = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-blue-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-blue = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bold-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bold = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-cyan = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-dim = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-gray = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-green = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-grey-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-grey = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-hidden-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-hidden = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-inverse-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-inverse = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-italic-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-italic = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-magenta-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-magenta = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-red-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-red = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-reset-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-reset = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-strikethrough-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-strikethrough = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-underline-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-underline = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-white-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-white = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-yellow-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-yellow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-error-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-info-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok-ansi-green = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok-success-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-success-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-time-stamp = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-warning-symbol = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-toggle-array-isobject = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-toggle-array = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-component-emitter = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-debug-ms = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-debug = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-arr-flatten = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-extend-shallow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-number-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-number = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-windows = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-koalas = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-mute-stream = "ISC"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-strip-color = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-is-number-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-is-number = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width-strip-ansi = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-arr-flatten = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-extend-shallow = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-number-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-number = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-windows = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-koalas = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-mute-stream = "ISC"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-strip-color = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-is-number-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-is-number = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-accessor-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-data-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-copy-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-accessor-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-data-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-kind-of-is-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-kind-of = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio-prompt-checkbox = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list-prompt-radio = "MIT"
LICENSE_${PN}-canboatjs-serialport-prompt-list = "MIT"
LICENSE_${PN}-canboatjs-serialport-safe-buffer = "MIT"
LICENSE_${PN}-canboatjs-serialport = "MIT"
LICENSE_${PN}-canboatjs-socketcan-nan = "MIT"
LICENSE_${PN}-canboatjs-socketcan-xml2js-sax = "ISC"
LICENSE_${PN}-canboatjs-socketcan-xml2js-xmlbuilder = "MIT"
LICENSE_${PN}-canboatjs-socketcan-xml2js = "MIT"
LICENSE_${PN}-canboatjs-socketcan = "Apache-2.0"
LICENSE_${PN}-canboatjs-split-through = "MIT Unknown"
LICENSE_${PN}-canboatjs-split = "MIT"
LICENSE_${PN}-canboatjs = "Apache-2.0"
LICENSE_${PN}-colors = "MIT"
LICENSE_${PN}-compare-versions = "MIT"
LICENSE_${PN}-cookie = "MIT"
LICENSE_${PN}-cors-object-assign = "MIT"
LICENSE_${PN}-cors-vary = "MIT"
LICENSE_${PN}-cors = "MIT"
LICENSE_${PN}-debug-ms = "MIT"
LICENSE_${PN}-debug = "MIT"
LICENSE_${PN}-deep-get-set = "MIT"
LICENSE_${PN}-dev-null-stream = "ISC"
LICENSE_${PN}-ejson-underscore = "MIT"
LICENSE_${PN}-ejson = "MIT"
LICENSE_${PN}-errorhandler-accepts-mime-types-mime-db = "MIT"
LICENSE_${PN}-errorhandler-accepts-mime-types = "MIT"
LICENSE_${PN}-errorhandler-accepts-negotiator = "MIT"
LICENSE_${PN}-errorhandler-accepts = "MIT"
LICENSE_${PN}-errorhandler-escape-html = "MIT"
LICENSE_${PN}-errorhandler = "MIT"
LICENSE_${PN}-express-accepts-mime-types-mime-db = "MIT"
LICENSE_${PN}-express-accepts-mime-types = "MIT"
LICENSE_${PN}-express-accepts-negotiator = "MIT"
LICENSE_${PN}-express-accepts = "MIT"
LICENSE_${PN}-express-array-flatten = "MIT"
LICENSE_${PN}-express-body-parser-bytes = "MIT"
LICENSE_${PN}-express-body-parser-content-type = "MIT"
LICENSE_${PN}-express-body-parser-debug-ms = "MIT"
LICENSE_${PN}-express-body-parser-debug = "MIT"
LICENSE_${PN}-express-body-parser-depd = "MIT"
LICENSE_${PN}-express-body-parser-http-errors-depd = "MIT"
LICENSE_${PN}-express-body-parser-http-errors-inherits = "ISC"
LICENSE_${PN}-express-body-parser-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-express-body-parser-http-errors-statuses = "MIT"
LICENSE_${PN}-express-body-parser-http-errors = "MIT"
LICENSE_${PN}-express-body-parser-iconv-lite = "MIT"
LICENSE_${PN}-express-body-parser-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-body-parser-on-finished = "MIT"
LICENSE_${PN}-express-body-parser-qs = "BSD-3-Clause"
LICENSE_${PN}-express-body-parser-raw-body-bytes = "MIT"
LICENSE_${PN}-express-body-parser-raw-body-http-errors-depd = "MIT"
LICENSE_${PN}-express-body-parser-raw-body-http-errors-inherits = "ISC"
LICENSE_${PN}-express-body-parser-raw-body-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-express-body-parser-raw-body-http-errors-statuses = "MIT"
LICENSE_${PN}-express-body-parser-raw-body-http-errors = "MIT"
LICENSE_${PN}-express-body-parser-raw-body-iconv-lite = "MIT"
LICENSE_${PN}-express-body-parser-raw-body-unpipe = "MIT"
LICENSE_${PN}-express-body-parser-raw-body = "MIT"
LICENSE_${PN}-express-body-parser-type-is-media-typer = "MIT"
LICENSE_${PN}-express-body-parser-type-is-mime-types-mime-db = "MIT"
LICENSE_${PN}-express-body-parser-type-is-mime-types = "MIT"
LICENSE_${PN}-express-body-parser-type-is = "MIT"
LICENSE_${PN}-express-body-parser = "MIT"
LICENSE_${PN}-express-content-disposition = "MIT"
LICENSE_${PN}-express-content-type = "MIT"
LICENSE_${PN}-express-cookie-signature = "MIT"
LICENSE_${PN}-express-cookie = "MIT"
LICENSE_${PN}-express-debug-ms = "MIT"
LICENSE_${PN}-express-debug = "MIT"
LICENSE_${PN}-express-depd = "MIT"
LICENSE_${PN}-express-encodeurl = "MIT"
LICENSE_${PN}-express-escape-html = "MIT"
LICENSE_${PN}-express-etag = "MIT"
LICENSE_${PN}-express-finalhandler-debug-ms = "MIT"
LICENSE_${PN}-express-finalhandler-debug = "MIT"
LICENSE_${PN}-express-finalhandler-encodeurl = "MIT"
LICENSE_${PN}-express-finalhandler-escape-html = "MIT"
LICENSE_${PN}-express-finalhandler-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-finalhandler-on-finished = "MIT"
LICENSE_${PN}-express-finalhandler-parseurl = "MIT"
LICENSE_${PN}-express-finalhandler-statuses = "MIT"
LICENSE_${PN}-express-finalhandler-unpipe = "MIT"
LICENSE_${PN}-express-finalhandler = "MIT"
LICENSE_${PN}-express-fresh = "MIT"
LICENSE_${PN}-express-merge-descriptors = "MIT"
LICENSE_${PN}-express-methods = "MIT"
LICENSE_${PN}-express-namespace-methods = "MIT"
LICENSE_${PN}-express-namespace = "Unknown"
LICENSE_${PN}-express-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-on-finished = "MIT"
LICENSE_${PN}-express-parseurl = "MIT"
LICENSE_${PN}-express-path-to-regexp = "MIT"
LICENSE_${PN}-express-proxy-addr-forwarded = "MIT"
LICENSE_${PN}-express-proxy-addr-ipaddr.js = "MIT"
LICENSE_${PN}-express-proxy-addr = "MIT"
LICENSE_${PN}-express-qs = "BSD-3-Clause"
LICENSE_${PN}-express-range-parser = "MIT"
LICENSE_${PN}-express-safe-buffer = "MIT"
LICENSE_${PN}-express-send-debug-ms = "MIT"
LICENSE_${PN}-express-send-debug = "MIT"
LICENSE_${PN}-express-send-depd = "MIT"
LICENSE_${PN}-express-send-destroy = "MIT"
LICENSE_${PN}-express-send-encodeurl = "MIT"
LICENSE_${PN}-express-send-escape-html = "MIT"
LICENSE_${PN}-express-send-etag = "MIT"
LICENSE_${PN}-express-send-fresh = "MIT"
LICENSE_${PN}-express-send-http-errors-depd = "MIT"
LICENSE_${PN}-express-send-http-errors-inherits = "ISC"
LICENSE_${PN}-express-send-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-express-send-http-errors-statuses = "MIT"
LICENSE_${PN}-express-send-http-errors = "MIT"
LICENSE_${PN}-express-send-mime = "MIT"
LICENSE_${PN}-express-send-ms = "MIT"
LICENSE_${PN}-express-send-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-send-on-finished = "MIT"
LICENSE_${PN}-express-send-range-parser = "MIT"
LICENSE_${PN}-express-send-statuses = "MIT"
LICENSE_${PN}-express-send = "MIT"
LICENSE_${PN}-express-serve-static-encodeurl = "MIT"
LICENSE_${PN}-express-serve-static-escape-html = "MIT"
LICENSE_${PN}-express-serve-static-parseurl = "MIT"
LICENSE_${PN}-express-serve-static-send-debug-ms = "MIT"
LICENSE_${PN}-express-serve-static-send-debug = "MIT"
LICENSE_${PN}-express-serve-static-send-depd = "MIT"
LICENSE_${PN}-express-serve-static-send-destroy = "MIT"
LICENSE_${PN}-express-serve-static-send-encodeurl = "MIT"
LICENSE_${PN}-express-serve-static-send-escape-html = "MIT"
LICENSE_${PN}-express-serve-static-send-etag = "MIT"
LICENSE_${PN}-express-serve-static-send-fresh = "MIT"
LICENSE_${PN}-express-serve-static-send-http-errors-depd = "MIT"
LICENSE_${PN}-express-serve-static-send-http-errors-inherits = "ISC"
LICENSE_${PN}-express-serve-static-send-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-express-serve-static-send-http-errors-statuses = "MIT"
LICENSE_${PN}-express-serve-static-send-http-errors = "MIT"
LICENSE_${PN}-express-serve-static-send-mime = "MIT"
LICENSE_${PN}-express-serve-static-send-ms = "MIT"
LICENSE_${PN}-express-serve-static-send-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-serve-static-send-on-finished = "MIT"
LICENSE_${PN}-express-serve-static-send-range-parser = "MIT"
LICENSE_${PN}-express-serve-static-send-statuses = "MIT"
LICENSE_${PN}-express-serve-static-send = "MIT"
LICENSE_${PN}-express-serve-static = "MIT"
LICENSE_${PN}-express-setprototypeof = "ISC"
LICENSE_${PN}-express-statuses = "MIT"
LICENSE_${PN}-express-type-is-media-typer = "MIT"
LICENSE_${PN}-express-type-is-mime-types-mime-db = "MIT"
LICENSE_${PN}-express-type-is-mime-types = "MIT"
LICENSE_${PN}-express-type-is = "MIT"
LICENSE_${PN}-express-utils-merge = "MIT"
LICENSE_${PN}-express-vary = "MIT"
LICENSE_${PN}-express = "MIT"
LICENSE_${PN}-file-timestamp-stream-ultra-strftime = "MIT"
LICENSE_${PN}-file-timestamp-stream = "MIT"
LICENSE_${PN}-flatmap = "MIT"
LICENSE_${PN}-geolib = "MIT"
LICENSE_${PN}-lodash = "MIT"
LICENSE_${PN}-mdns-bindings = "MIT"
LICENSE_${PN}-mdns-nan = "MIT"
LICENSE_${PN}-mdns = "MIT"
LICENSE_${PN}-minimist = "MIT"
LICENSE_${PN}-moment = "MIT"
LICENSE_${PN}-morgan-basic-auth-safe-buffer = "MIT"
LICENSE_${PN}-morgan-basic-auth = "MIT"
LICENSE_${PN}-morgan-debug-ms = "MIT"
LICENSE_${PN}-morgan-debug = "MIT"
LICENSE_${PN}-morgan-depd = "MIT"
LICENSE_${PN}-morgan-on-finished-ee-first = "MIT"
LICENSE_${PN}-morgan-on-finished = "MIT"
LICENSE_${PN}-morgan-on-headers = "MIT"
LICENSE_${PN}-morgan = "MIT"
LICENSE_${PN}-node-gpsd = "Unknown"
LICENSE_${PN}-pem-md5-charenc = "BSD-3-Clause"
LICENSE_${PN}-pem-md5-crypt = "BSD-3-Clause"
LICENSE_${PN}-pem-md5-is-buffer = "MIT"
LICENSE_${PN}-pem-md5 = "BSD-3-Clause"
LICENSE_${PN}-pem-os-tmpdir = "MIT"
LICENSE_${PN}-pem-safe-buffer = "MIT"
LICENSE_${PN}-pem-which-isexe = "ISC"
LICENSE_${PN}-pem-which = "ISC"
LICENSE_${PN}-pem = "MIT"
LICENSE_${PN}-please-upgrade-node = "MIT"
LICENSE_${PN}-primus-access-control-millisecond = "MIT"
LICENSE_${PN}-primus-access-control-setheader-debug = "Unknown"
LICENSE_${PN}-primus-access-control-setheader = "MIT"
LICENSE_${PN}-primus-access-control-vary = "MIT"
LICENSE_${PN}-primus-access-control = "MIT"
LICENSE_${PN}-primus-asyncemit = "MIT"
LICENSE_${PN}-primus-create-server-connected = "MIT"
LICENSE_${PN}-primus-create-server = "MIT"
LICENSE_${PN}-primus-diagnostics-colorspace-color-color-convert = "MIT"
LICENSE_${PN}-primus-diagnostics-colorspace-color-color-string-color-name = "MIT"
LICENSE_${PN}-primus-diagnostics-colorspace-color-color-string = "MIT"
LICENSE_${PN}-primus-diagnostics-colorspace-color = "MIT"
LICENSE_${PN}-primus-diagnostics-colorspace-text-hex = "MIT"
LICENSE_${PN}-primus-diagnostics-colorspace = "MIT"
LICENSE_${PN}-primus-diagnostics-enabled-env-variable = "MIT"
LICENSE_${PN}-primus-diagnostics-enabled = "MIT"
LICENSE_${PN}-primus-diagnostics-kuler-colornames = "MIT"
LICENSE_${PN}-primus-diagnostics-kuler = "MIT"
LICENSE_${PN}-primus-diagnostics = "MIT"
LICENSE_${PN}-primus-eventemitter3 = "MIT"
LICENSE_${PN}-primus-forwarded-for = "MIT"
LICENSE_${PN}-primus-fusing-emits = "MIT"
LICENSE_${PN}-primus-fusing-predefine-extendible = "MIT"
LICENSE_${PN}-primus-fusing-predefine = "MIT"
LICENSE_${PN}-primus-fusing = "MIT"
LICENSE_${PN}-primus-setheader-debug = "Unknown"
LICENSE_${PN}-primus-setheader = "MIT"
LICENSE_${PN}-primus-ultron = "MIT"
LICENSE_${PN}-primus-yeast = "MIT"
LICENSE_${PN}-primus = "MIT"
LICENSE_${PN}-serialport-bindings = "MIT"
LICENSE_${PN}-serialport-commander = "MIT"
LICENSE_${PN}-serialport-debug-ms = "MIT"
LICENSE_${PN}-serialport-debug = "MIT"
LICENSE_${PN}-serialport-nan = "MIT"
LICENSE_${PN}-serialport-prebuild-install-detect-libc = "Apache-2.0"
LICENSE_${PN}-serialport-prebuild-install-expand-template = "WTFPL"
LICENSE_${PN}-serialport-prebuild-install-github-from-package = "MIT"
LICENSE_${PN}-serialport-prebuild-install-minimist = "MIT"
LICENSE_${PN}-serialport-prebuild-install-mkdirp-minimist = "MIT"
LICENSE_${PN}-serialport-prebuild-install-mkdirp = "MIT"
LICENSE_${PN}-serialport-prebuild-install-node-abi-semver = "ISC"
LICENSE_${PN}-serialport-prebuild-install-node-abi = "MIT"
LICENSE_${PN}-serialport-prebuild-install-noop-logger = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-delegates = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-inherits = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-isarray = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet-readable-stream = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-are-we-there-yet = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-console-control-strings = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-aproba = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-console-control-strings = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-has-unicode = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-object-assign = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-signal-exit = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-string-width-code-point-at = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-string-width-strip-ansi = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-string-width = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-strip-ansi = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-code-point-at = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-wide-align-string-width-strip-ansi = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-wide-align-string-width = "MIT"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge-wide-align = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-gauge = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog-set-blocking = "ISC"
LICENSE_${PN}-serialport-prebuild-install-npmlog = "ISC"
LICENSE_${PN}-serialport-prebuild-install-os-homedir = "MIT"
LICENSE_${PN}-serialport-prebuild-install-pump-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-serialport-prebuild-install-pump-end-of-stream-once = "ISC"
LICENSE_${PN}-serialport-prebuild-install-pump-end-of-stream = "MIT"
LICENSE_${PN}-serialport-prebuild-install-pump-once-wrappy = "ISC"
LICENSE_${PN}-serialport-prebuild-install-pump-once = "ISC"
LICENSE_${PN}-serialport-prebuild-install-pump = "MIT"
LICENSE_${PN}-serialport-prebuild-install-rc-deep-extend = "MIT"
LICENSE_${PN}-serialport-prebuild-install-rc-ini = "ISC"
LICENSE_${PN}-serialport-prebuild-install-rc-minimist = "MIT"
LICENSE_${PN}-serialport-prebuild-install-rc-strip-json-comments = "MIT"
LICENSE_${PN}-serialport-prebuild-install-rc = "MIT Unknown"
LICENSE_${PN}-serialport-prebuild-install-simple-get-decompress-response-mimic-response = "MIT"
LICENSE_${PN}-serialport-prebuild-install-simple-get-decompress-response = "MIT"
LICENSE_${PN}-serialport-prebuild-install-simple-get-once-wrappy = "ISC"
LICENSE_${PN}-serialport-prebuild-install-simple-get-once = "ISC"
LICENSE_${PN}-serialport-prebuild-install-simple-get-simple-concat = "MIT"
LICENSE_${PN}-serialport-prebuild-install-simple-get = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-chownr = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-mkdirp-minimist = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-mkdirp = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-pump-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-pump-end-of-stream-once = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-pump-end-of-stream = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-pump-once-wrappy = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-pump-once = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-pump = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-inherits = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-isarray = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl-readable-stream = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-bl = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-end-of-stream-once = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-end-of-stream = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-inherits = "ISC"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-isarray = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-readable-stream = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream-xtend = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs-tar-stream = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tar-fs = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tunnel-agent-safe-buffer = "MIT"
LICENSE_${PN}-serialport-prebuild-install-tunnel-agent = "Apache-2.0"
LICENSE_${PN}-serialport-prebuild-install-which-pm-runs = "MIT"
LICENSE_${PN}-serialport-prebuild-install = "MIT"
LICENSE_${PN}-serialport-promirepl = "MIT"
LICENSE_${PN}-serialport-prompt-list-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-ansi-cyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-ansi-dim = "MIT"
LICENSE_${PN}-serialport-prompt-list-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-ansi-cyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-component-emitter = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-koalas = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblack-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblack = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblue-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgblue = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgcyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgcyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bggreen-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bggreen = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgmagenta-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgmagenta = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgred-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgred = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgwhite-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgwhite = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgyellow-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bgyellow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-black-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-black = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-blue-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-blue = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bold-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-bold = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-cyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-dim = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-gray = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-green = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-grey-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-grey = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-hidden-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-hidden = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-inverse-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-inverse = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-italic-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-italic = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-magenta-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-magenta = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-red-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-red = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-reset-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-reset = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-strikethrough-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-strikethrough = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-underline-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-underline = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-white-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-white = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-yellow-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-ansi-yellow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors-lazy-cache = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-ansi-colors = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-error-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-info-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok-ansi-green = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok-success-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-log-ok = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-success-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-time-stamp = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils-warning-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-log-utils = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-actions-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-actions-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-actions = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-for-own-for-in = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-for-own = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-is-plain-object-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-is-plain-object = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-mixin-object-for-in = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-mixin-object-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone-mixin-object = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep-shallow-clone = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-clone-deep = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property-is-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-define-property = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-koalas = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-flatten = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap-is-number-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap-is-number = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-arr-swap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-ansi-dim = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator-strip-color = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-choices-separator = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-for-own-for-in = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-for-own = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-is-plain-object-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-is-plain-object = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-mixin-object-for-in = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-mixin-object-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone-mixin-object = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep-shallow-clone = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-clone-deep = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-map-visit-object-visit-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-map-visit-object-visit = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-map-visit = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-object-visit-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit-object-visit = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-collection-visit = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property-is-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-define-property = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-extend-shallow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-is-number-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-is-number = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-koalas = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-lazy-cache = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblack-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblack = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblue-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgblue = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgcyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgcyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bggreen-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bggreen = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgmagenta-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgmagenta = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgred-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgred = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgwhite-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgwhite = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgyellow-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bgyellow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-black-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-black = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-blue-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-blue = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bold-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-bold = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-cyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-dim = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-gray = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-green = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-grey-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-grey = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-hidden-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-hidden = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-inverse-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-inverse = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-italic-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-italic = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-magenta-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-magenta = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-red-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-red = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-reset-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-reset = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-strikethrough-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-strikethrough = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-underline-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-underline = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-white-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-white = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-yellow-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-ansi-yellow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors-lazy-cache = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-ansi-colors = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-error-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-info-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok-ansi-green = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok-success-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-log-ok = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-success-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-time-stamp = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils-warning-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-log-utils = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-pointer-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-gray = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-ansi-green = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol-is-windows = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-radio-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-extend-shallow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-is-plain-object-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-is-plain-object = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-assign-symbols = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-is-extendable-is-plain-object-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-is-extendable-is-plain-object = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string-extend-shallow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value-split-string = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-set-value = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-strip-color = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-extend-shallow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblack-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblack = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblue-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgblue = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgcyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgcyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bggreen-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bggreen = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgmagenta-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgmagenta = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgred-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgred = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgwhite-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgwhite = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgyellow-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bgyellow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-black-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-black = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-blue-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-blue = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bold-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-bold = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-cyan-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-cyan = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-dim-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-dim = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-gray-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-gray = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-green = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-grey-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-grey = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-hidden-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-hidden = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-inverse-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-inverse = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-italic-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-italic = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-magenta-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-magenta = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-red-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-red = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-reset-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-reset = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-strikethrough-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-strikethrough = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-underline-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-underline = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-white-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-white = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-yellow-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-ansi-yellow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter-to-object-path = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache-set-getter = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors-lazy-cache = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-ansi-colors = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-error-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-info-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok-ansi-green-ansi-wrap = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok-ansi-green = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok-success-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-log-ok = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-success-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-time-stamp = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils-warning-symbol = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator-log-utils = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-terminal-paginator = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-toggle-array-isobject = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices-toggle-array = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question-prompt-choices = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-prompt-question = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-component-emitter = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-debug-ms = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-debug = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-arr-flatten = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-extend-shallow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-number-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-number = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-is-windows = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-koalas = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-mute-stream = "ISC"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-strip-color = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property-is-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-define-property = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-is-number-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size-is-number = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils-window-size = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-readline-utils = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width-strip-ansi = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui-string-width = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-ui = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-arr-flatten = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-extend-shallow = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-number-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-number = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-is-windows = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-koalas = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-mute-stream = "ISC"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-strip-color = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property-is-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-define-property = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-is-number-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-is-number-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size-is-number = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils-window-size = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-readline-utils = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-accessor-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-data-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property-is-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-define-property = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-copy-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-accessor-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-accessor-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-data-descriptor-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-is-data-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property-is-descriptor = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-define-property = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-kind-of-is-buffer = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy-kind-of = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend-object-copy = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base-static-extend = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox-prompt-base = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio-prompt-checkbox = "MIT"
LICENSE_${PN}-serialport-prompt-list-prompt-radio = "MIT"
LICENSE_${PN}-serialport-prompt-list = "MIT"
LICENSE_${PN}-serialport-safe-buffer = "MIT"
LICENSE_${PN}-serialport = "MIT"
LICENSE_${PN}-signalk-client-bluebird = "MIT"
LICENSE_${PN}-signalk-client-debug-ms = "MIT"
LICENSE_${PN}-signalk-client-debug = "MIT"
LICENSE_${PN}-signalk-client-eventemitter3 = "MIT"
LICENSE_${PN}-signalk-client-lodash = "MIT"
LICENSE_${PN}-signalk-client-superagent-component-emitter = "MIT"
LICENSE_${PN}-signalk-client-superagent-cookiejar = "MIT"
LICENSE_${PN}-signalk-client-superagent-debug-ms = "MIT"
LICENSE_${PN}-signalk-client-superagent-debug = "MIT"
LICENSE_${PN}-signalk-client-superagent-extend = "MIT"
LICENSE_${PN}-signalk-client-superagent-form-data-asynckit = "MIT"
LICENSE_${PN}-signalk-client-superagent-form-data-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-signalk-client-superagent-form-data-combined-stream = "MIT"
LICENSE_${PN}-signalk-client-superagent-form-data-mime-types-mime-db = "MIT"
LICENSE_${PN}-signalk-client-superagent-form-data-mime-types = "MIT"
LICENSE_${PN}-signalk-client-superagent-form-data = "MIT"
LICENSE_${PN}-signalk-client-superagent-formidable = "MIT"
LICENSE_${PN}-signalk-client-superagent-methods = "MIT"
LICENSE_${PN}-signalk-client-superagent-mime = "MIT"
LICENSE_${PN}-signalk-client-superagent-promise = "MIT"
LICENSE_${PN}-signalk-client-superagent-qs = "BSD-3-Clause"
LICENSE_${PN}-signalk-client-superagent-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-signalk-client-superagent-readable-stream-inherits = "ISC"
LICENSE_${PN}-signalk-client-superagent-readable-stream-isarray = "MIT"
LICENSE_${PN}-signalk-client-superagent-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-signalk-client-superagent-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-signalk-client-superagent-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-signalk-client-superagent-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-signalk-client-superagent-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-signalk-client-superagent-readable-stream = "MIT"
LICENSE_${PN}-signalk-client-superagent = "MIT"
LICENSE_${PN}-signalk-client-url-punycode = "MIT"
LICENSE_${PN}-signalk-client-url-querystring = "MIT"
LICENSE_${PN}-signalk-client-url = "MIT"
LICENSE_${PN}-signalk-client-ws-async-limiter = "MIT"
LICENSE_${PN}-signalk-client-ws-safe-buffer = "MIT"
LICENSE_${PN}-signalk-client-ws-ultron = "MIT"
LICENSE_${PN}-signalk-client-ws = "MIT"
LICENSE_${PN}-signalk-maptracker-d3 = "BSD-3-Clause"
LICENSE_${PN}-signalk-maptracker-jquery = "MIT"
LICENSE_${PN}-signalk-maptracker-js-quantities = "MIT"
LICENSE_${PN}-signalk-maptracker-leaflet = "Unknown BSD-2-Clause"
LICENSE_${PN}-signalk-maptracker-signalk-client-bluebird = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-debug-ms = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-debug = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-eventemitter3 = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-lodash = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-component-emitter = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-cookiejar = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-debug-ms = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-debug = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-extend = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-form-data-asynckit = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-form-data-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-form-data-combined-stream = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-form-data-mime-types-mime-db = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-form-data-mime-types = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-form-data = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-formidable = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-methods = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-mime = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-promise = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-qs = "BSD-3-Clause"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-inherits = "ISC"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-isarray = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent-readable-stream = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-superagent = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-url-punycode = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-url-querystring = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-url = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-ws-async-limiter = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-ws-safe-buffer = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-ws-ultron = "MIT"
LICENSE_${PN}-signalk-maptracker-signalk-client-ws = "MIT"
LICENSE_${PN}-signalk-n2k-signalk-JSONStream-jsonparse = "MIT"
LICENSE_${PN}-signalk-n2k-signalk-JSONStream-through = "MIT Unknown"
LICENSE_${PN}-signalk-n2k-signalk-JSONStream = "MIT Unknown"
LICENSE_${PN}-signalk-n2k-signalk-debug-ms = "MIT"
LICENSE_${PN}-signalk-n2k-signalk-debug = "MIT"
LICENSE_${PN}-signalk-n2k-signalk-through = "MIT Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-async-lodash = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-async = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-JSONSelect = "ISC"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint-JSV = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint-nomnom-chalk-ansi-styles = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint-nomnom-chalk-has-color = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint-nomnom-chalk-strip-ansi = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint-nomnom-chalk = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint-nomnom-underscore = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint-nomnom = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson-jsonlint = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-cjson = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-ebnf-parser = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-escodegen-esprima = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-escodegen-estraverse = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-escodegen-esutils = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-escodegen-source-map-amdefine = "(BSD-3-Clause_|_MIT)"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-escodegen-source-map = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-escodegen = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-esprima = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-jison-lex-lex-parser = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-jison-lex-nomnom-colors = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-jison-lex-nomnom-underscore = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-jison-lex-nomnom = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-jison-lex = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-lex-parser = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-nomnom-colors = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-nomnom-underscore = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison-nomnom = "Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder-jison = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-ggencoder = "apache20"
LICENSE_${PN}-signalk-nmea0183-signalk-lodash = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-moment-timezone-moment = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-moment-timezone = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-moment = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-JSONStream-jsonparse = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-JSONStream-through = "MIT Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-JSONStream = "MIT Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-debug-ms = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-debug = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-call-me-maybe = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-debug-ms = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-debug = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-es6-promise = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-js-yaml-argparse-sprintf-js = "BSD-3-Clause"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-js-yaml-argparse = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-js-yaml-esprima = "BSD-2-Clause"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-js-yaml = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-ono-format-util = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-ono = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-z-schema-commander = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-z-schema-lodash.get = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-z-schema-lodash.isequal = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-z-schema-validator = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser-z-schema = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-json-schema-ref-parser = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-lodash = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-tv4-formats-moment = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-tv4-formats-validator = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-tv4-formats = "MIT"
LICENSE_${PN}-signalk-nmea0183-signalk-signalk-signalk-schema-tv4 = "PD"
LICENSE_${PN}-signalk-nmea0183-signalk-split-through = "MIT Unknown"
LICENSE_${PN}-signalk-nmea0183-signalk-split = "MIT"
LICENSE_${PN}-signalk-signalk-schema-JSONStream-jsonparse = "MIT"
LICENSE_${PN}-signalk-signalk-schema-JSONStream-through = "MIT Unknown"
LICENSE_${PN}-signalk-signalk-schema-JSONStream = "MIT Unknown"
LICENSE_${PN}-signalk-signalk-schema-debug-ms = "MIT"
LICENSE_${PN}-signalk-signalk-schema-debug = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-call-me-maybe = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-debug-ms = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-debug = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-es6-promise = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-js-yaml-argparse-sprintf-js = "BSD-3-Clause"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-js-yaml-argparse = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-js-yaml-esprima = "BSD-2-Clause"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-js-yaml = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-ono-format-util = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-ono = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-z-schema-commander = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-z-schema-lodash.get = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-z-schema-lodash.isequal = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-z-schema-validator = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser-z-schema = "MIT"
LICENSE_${PN}-signalk-signalk-schema-json-schema-ref-parser = "MIT"
LICENSE_${PN}-signalk-signalk-schema-lodash = "MIT"
LICENSE_${PN}-signalk-signalk-schema-tv4-formats-moment = "MIT"
LICENSE_${PN}-signalk-signalk-schema-tv4-formats-validator = "MIT"
LICENSE_${PN}-signalk-signalk-schema-tv4-formats = "MIT"
LICENSE_${PN}-signalk-signalk-schema-tv4 = "PD"
LICENSE_${PN}-signalk-signalk-to-nmea0183-baconjs = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-browser-stdout = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-commander-graceful-readlink = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-commander = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-debug-ms = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-debug = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-diff = "BSD-3-Clause"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-escape-string-regexp = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-fs.realpath = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-inflight-once = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-inflight = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-inherits = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-minimatch = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-once-wrappy = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-once = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob-path-is-absolute = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-glob = "ISC"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-growl = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-he = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-json3 = "Unknown"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-baseassign-lodash.-basecopy = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-baseassign-lodash.keys-lodash.-getnative = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-baseassign-lodash.keys-lodash.isarguments = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-baseassign-lodash.keys-lodash.isarray = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-baseassign-lodash.keys = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-baseassign = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-basecreate = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create-lodash.-isiterateecall = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-lodash.create = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-mkdirp-minimist = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-mkdirp = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-supports-color-has-flag = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha-supports-color = "MIT"
LICENSE_${PN}-signalk-signalk-to-nmea0183-mocha = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-nan = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-mkdirp-minimist = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-mkdirp = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-nopt-abbrev = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-nopt-osenv-os-homedir = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-nopt-osenv-os-tmpdir = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-nopt-osenv = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-nopt = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-delegates = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-isarray = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-are-we-there-yet = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-console-control-strings = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-aproba = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-console-control-strings = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-has-unicode = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-object-assign = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-signal-exit = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-string-width-code-point-at = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-string-width-strip-ansi = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-string-width = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-strip-ansi = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-code-point-at = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-strip-ansi = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge-wide-align = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-gauge = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog-set-blocking = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-npmlog = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rc-deep-extend = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rc-ini = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rc-minimist = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rc-strip-json-comments = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rc = "MIT Unknown"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-aws-sign2 = "Apache-2.0"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-aws4 = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-caseless = "Apache-2.0"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-combined-stream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-extend = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-forever-agent = "Apache-2.0"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-form-data-asynckit = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-form-data-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-form-data-combined-stream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-form-data-mime-types-mime-db = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-form-data-mime-types = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-form-data = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-har-validator-ajv-co = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-har-validator-ajv-fast-deep-equal = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-har-validator-ajv-fast-json-stable-stringify = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-har-validator-ajv-json-schema-traverse = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-har-validator-ajv = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-har-validator-har-schema = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-har-validator = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-boom = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-cryptiles-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-cryptiles-boom = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-cryptiles = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-hoek = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-sntp-hoek = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk-sntp = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-hawk = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-assert-plus = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim-assert-plus = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim-extsprintf = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim-json-schema = "Unknown"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim-verror-assert-plus = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim-verror-core-util-is = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim-verror-extsprintf = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim-verror = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-jsprim = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-asn1 = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-assert-plus = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-bcrypt-pbkdf-tweetnacl = "Unlicense"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-bcrypt-pbkdf = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-dashdash-assert-plus = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-dashdash = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-ecc-jsbn-jsbn = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-ecc-jsbn = "MIT Unknown"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-getpass-assert-plus = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-getpass = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-jsbn = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk-tweetnacl = "Unlicense"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature-sshpk = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-http-signature = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-is-typedarray = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-isstream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-json-stringify-safe = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-mime-types-mime-db = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-mime-types = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-oauth-sign = "Apache-2.0"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-performance-now = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-qs = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-stringstream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-tough-cookie-punycode = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-tough-cookie = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-tunnel-agent-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-tunnel-agent = "Apache-2.0"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request-uuid = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-request = "Apache-2.0"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf-glob = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-rimraf = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-semver = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-block-stream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-block-stream = "ISC Unknown"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-graceful-fs = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-mkdirp = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream-rimraf = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-fstream = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-debug-ms = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-debug = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-graceful-fs = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-graceful-fs = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-mkdirp = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-ignore = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-mkdirp = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-fstream = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-isarray = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-readable-stream = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf-glob = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-rimraf = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-block-stream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-block-stream = "ISC Unknown"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-graceful-fs = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-mkdirp = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-fstream = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-tar = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack-uid-number = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar-pack = "BSD-2-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp-tar = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt-node-pre-gyp = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-bcrypt = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-bytes = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-content-type = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-debug-ms = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-debug = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-depd = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-http-errors-depd = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-http-errors-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-http-errors-statuses = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-http-errors = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-iconv-lite = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-on-finished-ee-first = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-on-finished = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-qs = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-bytes = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-http-errors-depd = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-http-errors-inherits = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-http-errors-statuses = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-http-errors = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-iconv-lite = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body-unpipe = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-raw-body = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-type-is-media-typer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-type-is-mime-types-mime-db = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-type-is-mime-types = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser-type-is = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-body-parser = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-cookie-parser-cookie-signature = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-cookie-parser-cookie = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-cookie-parser = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-debug-ms = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-debug = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-lodash = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-joi-hoek = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-joi-isemail = "BSD-2-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-joi-moment = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-joi-topo-hoek = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-joi-topo = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-joi = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-base64url = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-jwa-base64url = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-jwa-buffer-equal-constant-time = "BSD-3-Clause"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-jwa-ecdsa-sig-formatter-base64url = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-jwa-ecdsa-sig-formatter-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-jwa-ecdsa-sig-formatter = "Apache-2.0"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-jwa-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-jwa = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws-safe-buffer = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-jws = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-lodash.once = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-ms = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken-xtend = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-jsonwebtoken = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt-passport-strategy = "MIT"
LICENSE_${PN}-signalk-sk-simple-token-security-passport-jwt = "MIT"
LICENSE_${PN}-signalk-zones-baconjs = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-JSONStream-jsonparse = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-JSONStream-through = "MIT Unknown"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-JSONStream = "MIT Unknown"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-debug-ms = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-debug = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-call-me-maybe = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-debug-ms = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-debug = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-es6-promise = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-js-yaml-argparse-sprintf-js = "BSD-3-Clause"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-js-yaml-argparse = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-js-yaml-esprima = "BSD-2-Clause"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-js-yaml = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-ono-format-util = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-ono = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-z-schema-commander = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-z-schema-lodash.get = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-z-schema-lodash.isequal = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-z-schema-validator = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser-z-schema = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-json-schema-ref-parser = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-lodash = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-tv4-formats-moment = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-tv4-formats-validator = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-tv4-formats = "MIT"
LICENSE_${PN}-signalk-zones-signalk-signalk-schema-tv4 = "PD"
LICENSE_${PN}-split-through = "MIT Unknown"
LICENSE_${PN}-split = "MIT"
LICENSE_${PN}-stat-mode = "MIT"
LICENSE_${PN}-stream-throttle-commander = "MIT"
LICENSE_${PN}-stream-throttle-limiter = "MIT"
LICENSE_${PN}-stream-throttle = "BSD-3-Clause"
LICENSE_${PN}-through = "MIT Unknown"
LICENSE_${PN}-uuid = "MIT"
LICENSE_${PN}-ws-async-limiter = "MIT"
LICENSE_${PN}-ws-safe-buffer = "MIT"
LICENSE_${PN}-ws = "MIT"
LICENSE_${PN}-xml2js-sax = "ISC"
LICENSE_${PN}-xml2js-xmlbuilder = "MIT"
LICENSE_${PN}-xml2js = "MIT"
LICENSE_${PN} = "BSD-2-Clause MIT Unknown"


