## conf/machine/qemux86-extra.conf
```bitbake
QB_CPU_x86_qemux86 = "-cpu qemu32"
QB_CPU_KVM_x86_qemux86 = "-cpu kvm32"
QB_MEM_qemux86 = "-m 1024"
```
